## zephyr/Kconfig
```kconfig
config LIBOPUS
	bool "Enable Opus codec library"
	help
	  Enable Opus codec library.
```
